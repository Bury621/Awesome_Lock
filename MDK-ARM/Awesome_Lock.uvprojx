# Keil uVision project Awesome_Lock.uvprojx, settings and files
target Awesome_Lock (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Awesome_Lock +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;                                                                    ..\Drivers\STM32F4xx_HAL_Driver\Inc;                                                                    ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;                                                                    ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;                                                                    ..\Drivers\CMSIS\Include;                                                                    ..\App;                                                                    ..\Hardware;                                                                    ..\Service;                                                                    ..\Config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Inc/: main.h stm32f4xx_hal_conf.h
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App
    ../App/: App.c App.h Debug.c Debug.h
  group Hardware
    ../Hardware/: Keyboard.c Keyboard.h stepper_motor.c stepper_motor.h lcd_font.h lcd.c lcd.h lcd_font.c flash_eeprom.c flash_eeprom.h Fingerprint.c Fingerprint.h lcd_menu.c lcd_menu.h
  group Service
    ../Service/: UserInterface.c UserInterface.h multi_timer.c multi_timer.h
  group Config
    ../Config/: Config.h
software components: CMSIS:CORE 6.1.1
